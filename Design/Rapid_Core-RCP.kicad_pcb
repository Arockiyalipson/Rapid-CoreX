# Repository Arockiyalipson/Rapid-CoreX (continued)

## KiCad design Design/Rapid_Core-RCP.kicad_pcb (continued)

Schematic: Comm - LIN.kicad_sch, Rapid-Core

Parts:
C45, C46: 220uF, 0805; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C47, C49: 10uF, 10V, 0805; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C48, C50: 0u1F, 10V, 0603; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3, D4: D; D_SOD-323_HandSoldering
IC3, IC4: TLIN1039DDFRQ1; SOT65P280X110-8N; Mouser Part Number 595-TLIN1039DDFRQ1
J8: LIN-2; PinHeader_1x02_P2.54mm_Vertical
J9: LIN-1; PinHeader_1x02_P2.54mm_Vertical
J10: LIN-1; MOLEX_530480210; PARTREV A
J11: LIN-2; MOLEX_530480210; PARTREV A
R22, R23: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24, R25: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP14, TP15: TestPoint; TestPoint_Pad_D1.0mm

Connections:
+5V: C47.1, C48.1, C49.1, C50.1, D3.2 (A), D4.2 (A), IC3.7 (VSUP), IC4.7 (VSUP), R22.1, R23.1; also elsewhere on the board
/Project_Architecture/Comm - LIN/LIN1: C45.1, IC3.6 (LIN), J9.2, J10.2, TP15.1
/Project_Architecture/Comm - LIN/LIN1_CMD: D4.1 (K), R25.2
/Project_Architecture/Comm - LIN/LIN1_CMD_R: J9.1, R25.1
/Project_Architecture/Comm - LIN/LIN1_EN: IC3.2 (EN); also elsewhere on the board
/Project_Architecture/Comm - LIN/LIN1_RX: IC3.1 (RXD), R23.2; also elsewhere on the board
/Project_Architecture/Comm - LIN/LIN1_TX: IC3.4 (TXD); also elsewhere on the board
/Project_Architecture/Comm - LIN/LIN2: C46.1, IC4.6 (LIN), J8.2, J11.2, TP14.1
/Project_Architecture/Comm - LIN/LIN2_CMD: D3.1 (K), R24.2
/Project_Architecture/Comm - LIN/LIN2_CMD_R: J8.1, R24.1
/Project_Architecture/Comm - LIN/LIN2_EN: IC4.2 (EN); also elsewhere on the board
/Project_Architecture/Comm - LIN/LIN2_RX: IC4.1 (RXD), R22.2; also elsewhere on the board
/Project_Architecture/Comm - LIN/LIN2_TX: IC4.4 (TXD); also elsewhere on the board
GND1: C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, IC3.5 (GND), IC4.5 (GND), J10.1, J11.1; also elsewhere on the board

Notes on the sheet:
Part No: D3 : 1N4448WSF-7
Part No: D4 : 1N4448WSF-7
DESIGN NOTE: 1. If J9 is closed the tranceiver acts a Commander. 2. If J9 is open the transceiver acts a Responder.
PWR LIN_2
[${#}] ${SHEETNAME}
LIN - 2
LIN - 1

Schematic: Comm - Isolated_RS-485.kicad_sch, Rapid-Core

Parts:
C51, C52, C57, C58: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C53, C54, C59, C61: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C55, C56, C62, C64: 10uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C60, C63: 4700pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D5: SM712_SOT23; SOT-23; MANUFACTURER PART NO CDSOT23-SM712
D6: SM712_SOT23; SOT-23
J12: RS-485-1; MOLEX_530480210; MANUFACTURER PART NO 0530480210
J13: RS-485-2; MOLEX_530480210; PARTREV A
L4, L5: ACT45B-510-2P-TL003; IND_ACT45R_TDK; MANUFACTURER PART NO 744235510
R26, R27, R28, R29, R30, R31, R32, R33, R34, R35: 0 RS; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R36, R37, R38, R39: 10k , RS; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R40, R41, R42, R43: 59; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25: TestPoint; TestPoint_Pad_D1.0mm
U7, U8: ISO3082DW; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
+3.3V: C51.1, C52.1, C53.1, C54.1, C55.2, C56.2, U7.1 (Vcc1), U8.1 (Vcc1); also elsewhere on the board
+5VA: C57.1, C58.1, C59.1, C61.1, C62.2, C64.2, R37.2, R39.2, U7.16 (Vcc2), U8.16 (Vcc2); also elsewhere on the board
/Project_Architecture/Comm - Isolated_RS-485/RS-485_1_Cap: C60.1, R40.2, R41.1
/Project_Architecture/Comm - Isolated_RS-485/RS-485_1_EN: R28.1; also elsewhere on the board
/Project_Architecture/Comm - Isolated_RS-485/RS-485_1_EN_R-1: R28.2, TP19.1, U7.4 (~RE), U7.5 (DE)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_1_RX: R27.1; also elsewhere on the board
/Project_Architecture/Comm - Isolated_RS-485/RS-485_1_RX_R-1: R27.2, TP20.1, U7.3 (R)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_1_TX: R26.1; also elsewhere on the board
/Project_Architecture/Comm - Isolated_RS-485/RS-485_1_TX_R-1: R26.2, TP16.1, U7.6 (D)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_2_Cap: C63.1, R42.2, R43.1
/Project_Architecture/Comm - Isolated_RS-485/RS-485_2_EN: R31.1; also elsewhere on the board
/Project_Architecture/Comm - Isolated_RS-485/RS-485_2_EN_R-2: R31.2, TP21.1, U8.4 (~RE), U8.5 (DE)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_2_RX: R30.1; also elsewhere on the board
/Project_Architecture/Comm - Isolated_RS-485/RS-485_2_RX_R-2: R30.2, TP18.1, U8.3 (R)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_2_TX: R29.1; also elsewhere on the board
/Project_Architecture/Comm - Isolated_RS-485/RS-485_2_TX_R-2: R29.2, TP17.1, U8.6 (D)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_A-1: L4.2, R33.1, R39.1, U7.12 (A)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_A-2: L5.2, R34.1, R37.1, U8.12 (A)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_A-IN-1: D5.2 (A2), J12.1, L4.3, R33.2, R41.2, TP23.1
/Project_Architecture/Comm - Isolated_RS-485/RS-485_A_IN-2: D6.2 (A2), J13.1, L5.3, R34.2, R43.2, TP25.1
/Project_Architecture/Comm - Isolated_RS-485/RS-485_B-1: L4.1, R32.1, R38.1, U7.13 (B)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_B-2: L5.1, R35.1, R36.1, U8.13 (B)
/Project_Architecture/Comm - Isolated_RS-485/RS-485_B_IN-1: D5.1 (A1), J12.2, L4.4, R32.2, R40.1, TP22.1
/Project_Architecture/Comm - Isolated_RS-485/RS-485_B_IN-2: D6.1 (A1), J13.2, L5.4, R35.2, R42.1, TP24.1
GND1: C51.2, C52.2, C53.2, C54.2, C55.1, C56.1, U7.2 (GND1), U7.7 (GND1), U7.8 (GND1), U8.2 (GND1), U8.7 (GND1), U8.8 (GND1); also elsewhere on the board
GND2: C57.2, C58.2, C59.2, C60.2, C61.2, C62.1, C63.2, C64.1, D5.3 (common), D6.3 (common), R36.2, R38.2, U7.9 (GND2), U7.10 (GND2), U7.15 (GND2), U8.9 (GND2), U8.10 (GND2), U8.15 (GND2); also elsewhere on the board

Notes on the sheet:
[${#}] ${SHEETNAME}
Isolated RS_485 - 2
RS-485 2
Isolated RS_485 - 1

Schematic: General.kicad_sch, Rapid-Core

Parts:
C30: 0u1F; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J2: GPIO_CONN_X_4; PinHeader_1x06_P2.54mm_Vertical
J3: SPI; PinHeader_1x05_P2.54mm_Vertical
J4: USART; PinHeader_1x04_P2.54mm_Vertical
J5: SWD_Debug; PinHeader_1x05_P2.54mm_Vertical
R9: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
SW1: SW_Push; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS

Connections:
+3.3V: J2.1, J3.1, J4.1, J5.1, R9.2; also elsewhere on the board
/Project_Architecture/GPIO/GPIO_1_PB0: J2.2; also elsewhere on the board
/Project_Architecture/GPIO/GPIO_1_PB1: J2.3; also elsewhere on the board
/Project_Architecture/GPIO/GPIO_1_PB2: J2.4; also elsewhere on the board
/Project_Architecture/GPIO/GPIO_1_PB3: J2.5; also elsewhere on the board
/Project_Architecture/GPIO/NRST: C30.1, J5.3, R9.1, SW1.1; also elsewhere on the board
/Project_Architecture/GPIO/SPI1_MISO: J3.3; also elsewhere on the board
/Project_Architecture/GPIO/SPI1_MOSI: J3.4; also elsewhere on the board
/Project_Architecture/GPIO/SPI1_SCK: J3.2; also elsewhere on the board
/Project_Architecture/GPIO/SWDIO: J5.4; also elsewhere on the board
/Project_Architecture/GPIO/SW_CLK: J5.2; also elsewhere on the board
/Project_Architecture/GPIO/USART2_RX: J4.3; also elsewhere on the board
/Project_Architecture/GPIO/USART2_TX: J4.2; also elsewhere on the board
GND1: C30.2, J2.6, J3.5, J4.4, J5.5, SW1.2; also elsewhere on the board

Notes on the sheet:
DESCRIPTION: External USART/UART device can be connected ex: Memory card or any other sensors
DESCRIPTION: External GPIO Controllable Devices can be connected and controlled
DESCRIPTION: External SPI device can be connected ex: Memory card or any other sensors
LAYOUT NOTE: Do not use via on clk and IO line
DESCRIPTION: Debug Interface for MCU
Part No: SW1 : PTS636SK25FSMTR LFS
External SPI
SWD Debug
[${#}] ${SHEETNAME}
NRST Button
External USART/UART
GPIO Pins

Board: 4 copper layers, 194 parts (0 on the bottom side), 93 nets, no tracks yet.
